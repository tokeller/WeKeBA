# Keil uVision project mbed_CAN.uvproj, settings and files
target NXP LPC4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: mbed_CAN
  AfterMake: fromelf --bin -o build\mbed_CAN_LPC4088.bin build\mbed_CAN.axf
  c flags: Optim=1
  c define: TARGET_LPC4088,  TARGET_M4,  TARGET_NXP,  TARGET_LPC408X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M4,  ARM_MATH_CM4,  __FPU_PRESENT=1,  MBED_BUILD_TIMESTAMP=1409856453.8,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu
  c include: .;  mbed-src;  mbed-src/hal;  mbed-src/api;  mbed-src/targets;  mbed-src/targets/hal;  mbed-src/targets/hal/TARGET_NXP;  mbed-src/targets/hal/TARGET_NXP/TARGET_LPC408X;  mbed-src/targets/cmsis;  mbed-src/targets/cmsis/TARGET_NXP;  mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X;  mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/TOOLCHAIN_ARM_STD;  mbed-src/common;  CANTestingA;  mbed
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/TOOLCHAIN_ARM_STD/LPC407X_8X.sct
  link misc: --any_placement=first_fit
  group src
    mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/TOOLCHAIN_ARM_STD/: startup_LPC407x_8x_177x_8x.s sys_helper.cpp sys.cpp
    mbed-src/targets/hal/TARGET_NXP/TARGET_LPC408X/: port_api.c spi_api.c analogout_api.c analogin_api.c gpio_api.c rtc_api.c gpio_irq_api.c serial_api.c i2c_api.c pwmout_api.c ethernet_api.c sleep.c pinmap.c us_ticker.c can_api.c
    mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/: cmsis_nvic.c system_LPC407x_8x_177x_8x.c
    mbed-src/common/: board.c assert.c mbed_interface.c exit.c rtc_time.c us_ticker_api.c pinmap_common.c error.c gpio.c semihost_api.c wait_api.c RawSerial.cpp Ticker.cpp FilePath.cpp I2C.cpp FileBase.cpp retarget.cpp Serial.cpp Stream.cpp FileSystemLike.cpp CallChain.cpp InterruptManager.cpp SerialBase.cpp BusInOut.cpp SPISlave.cpp I2CSlave.cpp FunctionPointer.cpp Timer.cpp SPI.cpp Timeout.cpp Ethernet.cpp TimerEvent.cpp CAN.cpp BusOut.cpp FileLike.cpp BusIn.cpp InterruptIn.cpp LocalFileSystem.cpp
    CANTestingA/: main.cpp
