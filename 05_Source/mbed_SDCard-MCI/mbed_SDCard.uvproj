# Keil uVision project mbed_SDCard.uvproj, settings and files
target NXP LPC4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: mbed_SDCard
  AfterMake: fromelf --bin -o build\mbed_SDCard_LPC4088.bin build\mbed_SDCard.axf
  c flags: Optim=1
  c define: TARGET_LPC4088,  TARGET_M4,  TARGET_NXP,  TARGET_LPC408X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M4,  ARM_MATH_CM4,  __FPU_PRESENT=1,  MBED_BUILD_TIMESTAMP=1411476872.62,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu
  c include: .;  EALib;  EALib/FATFileSystem;  EALib/FATFileSystem/ChaN;  mbed;  mbed/TARGET_LPC4088;  mbed/TARGET_LPC4088/TARGET_NXP;  mbed/TARGET_LPC4088/TARGET_NXP/TARGET_LPC408X;  mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/LPC407X_8X.sct
  link misc: mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/sys_helper.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/startup_LPC407x_8x_177x_8x.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/system_LPC407x_8x_177x_8x.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/mbed.ar
            
                --any_placement=first_fit
  group src
    EALib/: glcdfont.c TSC2046.cpp gpdma.cpp GFXFb.cpp Adafruit_GFX.cpp sdram.cpp MMA7455.cpp SPIFI.cpp AR1021.cpp QSPIFileSystem.cpp LcdController.cpp EaLcdBoard.cpp XBee.cpp MCIFileSystem.cpp
    ./: main.cpp
    EALib/FATFileSystem/: FATFileSystem.cpp FATFileHandle.cpp FATDirHandle.cpp
    EALib/FATFileSystem/ChaN/: diskio.cpp ccsbcs.cpp ff.cpp
