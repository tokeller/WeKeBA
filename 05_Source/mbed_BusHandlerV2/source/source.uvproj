# Keil uVision project source.uvproj, settings and files
target NXP LPC4088 (ARM-ADS)
  device: LPC4088 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: source
  AfterMake: fromelf --bin -o build\source_LPC4088.bin build\source.axf
  c flags: Optim=1
  c define: TARGET_LPC4088,  TARGET_M4,  TARGET_CORTEX_M,  TARGET_NXP,  TARGET_LPC408X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M4,  ARM_MATH_CM4,  __FPU_PRESENT=1,  MBED_BUILD_TIMESTAMP=1416915036.73,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;.\HAL\EALib;.\HAL\EALib\FATFileSystem;.\HAL\EALib\FATFileSystem\ChaN;HAL/mbed-src;HAL/mbed-src/targets;HAL/mbed-src/targets/cmsis;HAL/mbed-src/targets/cmsis/TARGET_NXP;HAL/mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X;HAL/mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/TOOLCHAIN_ARM_STD;HAL/mbed-src/targets/hal;HAL/mbed-src/targets/hal/TARGET_NXP;HAL/mbed-src/targets/hal/TARGET_NXP/TARGET_LPC408X;HAL/mbed-src/common;HAL/mbed-src/api;HAL/mbed-src/hal;HAL/mbed-rtos;HAL/mbed-rtos/rtx;HAL/mbed-rtos/rtx/TARGET_CORTEX_M;HAL/mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M4;HAL/mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M4/TOOLCHAIN_ARM;HAL/mbed-rtos/rtos;app/;app/Support/;app/BusProtocol/;app/CommandLine/;app/ImpactDetection/
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: HAL/mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/TOOLCHAIN_ARM_STD/LPC407X_8X.sct
  link misc: --any_placement=first_fit
  group src
    HAL/mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/TOOLCHAIN_ARM_STD/: startup_LPC407x_8x_177x_8x.s sys.cpp sys_helper.cpp
    HAL/mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M4/TOOLCHAIN_ARM/: SVC_Table.s HAL_CM4.c
    HAL/mbed-src/targets/cmsis/TARGET_NXP/TARGET_LPC408X/: cmsis_nvic.c system_LPC407x_8x_177x_8x.c
    HAL/mbed-src/targets/hal/TARGET_NXP/TARGET_LPC408X/: analogin_api.c spi_api.c gpio_api.c i2c_api.c analogout_api.c rtc_api.c can_api.c port_api.c pwmout_api.c serial_api.c sleep.c gpio_irq_api.c pinmap.c ethernet_api.c us_ticker.c
    HAL/mbed-src/common/: exit.c wait_api.c board.c semihost_api.c pinmap_common.c us_ticker_api.c assert.c gpio.c error.c mbed_interface.c rtc_time.c RawSerial.cpp Stream.cpp Timeout.cpp LocalFileSystem.cpp FunctionPointer.cpp I2CSlave.cpp FilePath.cpp InterruptManager.cpp BusOut.cpp Timer.cpp FileSystemLike.cpp I2C.cpp CAN.cpp SPISlave.cpp TimerEvent.cpp Serial.cpp SPI.cpp SerialBase.cpp Ethernet.cpp retarget.cpp CallChain.cpp BusIn.cpp Ticker.cpp InterruptIn.cpp FileLike.cpp BusInOut.cpp FileBase.cpp
    HAL/mbed-rtos/rtx/TARGET_CORTEX_M/: rt_Task.c rt_MemBox.c rt_Robin.c rt_Mailbox.c rt_System.c rt_CMSIS.c rt_Event.c rt_Semaphore.c RTX_Conf_CM.c rt_Time.c rt_Mutex.c rt_List.c HAL_CM.c
    ./: main.cpp
    HAL/mbed-rtos/rtos/: RtosTimer.cpp Thread.cpp Mutex.cpp Semaphore.cpp
    ./app/BusProtocol/: BusProtocol.cpp BusHandler.cpp
    ./app/Support/: SerialID.cpp file_ops.cpp UART_RTOS_Interrupt.cpp
    ./app/ImpactDetection/: ADC_4088.cpp impact_action.cpp impact_event.cpp impact_fsm.cpp
    ./HAL/EALib/: sdram.cpp MCIFileSystem.cpp gpdma.cpp
    ./app/: ProcessingLoops.cpp
    ./app/CommandLine/: cmd.cpp cmd_action.cpp sensor_config.cpp
    ./HAL/EALib/FATFileSystem/: FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    ./HAL/EALib/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp ff.cpp
