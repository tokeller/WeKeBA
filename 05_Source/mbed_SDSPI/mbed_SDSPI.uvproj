# Keil uVision project mbed_SDSPI.uvproj, settings and files
target NXP LPC4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: mbed_SDSPI
  AfterMake: fromelf --bin -o build\mbed_SDSPI_LPC4088.bin build\mbed_SDSPI.axf
  c flags: Optim=1
  c define: TARGET_LPC4088,  TARGET_M4,  TARGET_NXP,  TARGET_LPC408X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M4,  ARM_MATH_CM4,  __FPU_PRESENT=1,  MBED_BUILD_TIMESTAMP=1411390126.69,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu
  c include: .;  mbed;  mbed/TARGET_LPC4088;  mbed/TARGET_LPC4088/TARGET_NXP;  mbed/TARGET_LPC4088/TARGET_NXP/TARGET_LPC408X;  mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD;  SDFileSystem;  SDFileSystem/FATFileSystem;  SDFileSystem/FATFileSystem/ChaN
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/LPC407X_8X.sct
  link misc: mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/sys_helper.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/startup_LPC407x_8x_177x_8x.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/system_LPC407x_8x_177x_8x.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/mbed.ar
            
                --any_placement=first_fit
  group src
    ./: main.cpp
    SDFileSystem/: SDFileSystem.cpp
    SDFileSystem/FATFileSystem/: FATFileSystem.cpp FATFileHandle.cpp FATDirHandle.cpp
    SDFileSystem/FATFileSystem/ChaN/: diskio.cpp ccsbcs.cpp ff.cpp
